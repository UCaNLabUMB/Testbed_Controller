options:
  parameters:
    generate_options: qt_gui
    id: USRP_Rx
    output_language: python
    title: USRP Receiver
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
