options:
  parameters:
    author: MR
    generate_options: no_gui
    id: Rx_general_Pluto
    output_language: python
    run_options: run
    title: 'Pi receiver script '
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '2000'
    max_iter: '500'
    scale: 1/2000
    type: float
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Center Frequency
    short_id: c
    type: eng_float
    value: '915000000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1000000'
    bbdc: 'True'
    buffer_size: '16384'
    filter_source: '''Auto'''
    frequency: fc
    gain1: '''hybrid'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: node
  id: parameter
  parameters:
    label: Node Number
    short_id: n
    type: str
    value: '101'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: 'Receiver Gain '
    short_id: g
    type: eng_float
    value: '40'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: a
    type: eng_float
    value: '3000000'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: '"10.1.1." + node'
    port: '8081'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://10.1.1."+node+":55555"'
    hwm: '1'
    timeout: '100'
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', zeromq_pub_sink_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
