options:
  parameters:
    generate_options: qt_gui
    id: Rx_GUI
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: parameter
  parameters:
    label: Center frequency
    short_id: c
    type: eng_float
    value: 915e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    short_id: g
    type: eng_float
    value: '40'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    short_id: r
    type: eng_float
    value: 3e6
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
